# Repository haknkayaa/VirtualDeviceSimulatorForEmbedded (continued)

## KiCad design hardware/bridge-one/cad/schematic/bridge-one.kicad_pcb (continued)

Schematic: translators.kicad_sch, VDS4E Bridge One - Target level translators (A = +3V3 side,…

Parts:
C49, C51: 10n; C_0402_1005Metric
C50, C52, C53, C54, C55, C56, C57, C58, C59, C60, C61, C62: 100n; C_0402_1005Metric
R47, R49: 200k; R_0402_1005Metric
R48, R50: 2.2M; R_0402_1005Metric
R51, R52, R53, R54: 4k7; R_0402_1005Metric
R55, R56, R64, R73, R74, R75, R76, R77, R78, R79, R80: 33R; R_0402_1005Metric
R57, R58, R59, R60, R61, R62, R63: 100k; R_0402_1005Metric
R65, R66, R67, R68, R69, R70, R71, R72: 10k; R_0402_1005Metric
R87, R88, R89, R90: 4k7 DNP; R_0402_1005Metric; not fitted
U6, U7, U10: SN74AVC4T245RSV; UQFN-16_1.8x2.6mm_P0.4mm; MPN SN74AVC4T245RSVR
U8, U9: PCA9306DCU; VSSOP-8_2.3x2mm_P0.5mm; MPN PCA9306DCUR
U11, U13: SN74AXC4T774RSV; UQFN-16_1.8x2.6mm_P0.4mm; MPN SN74AXC4T774RSVR

Connections:
GPIO0_RAW: R73.1, U11.12 (B1)
GPIO0_TGT: R73.2; also elsewhere on the board
GPIO1_RAW: R74.1, U11.11 (B2)
GPIO1_TGT: R74.2; also elsewhere on the board
GPIO2_RAW: R75.1, U11.10 (B3)
GPIO2_TGT: R75.2; also elsewhere on the board
GPIO3_RAW: R76.1, U11.9 (B4)
GPIO3_TGT: R76.2; also elsewhere on the board
GPIO4_RAW: R77.1, U13.12 (B1)
GPIO4_TGT: R77.2; also elsewhere on the board
GPIO5_RAW: R78.1, U13.11 (B2)
GPIO5_TGT: R78.2; also elsewhere on the board
GPIO6_RAW: R79.1, U13.10 (B3)
GPIO6_TGT: R79.2; also elsewhere on the board
GPIO7_RAW: R80.1, U13.9 (B4)
GPIO7_TGT: R80.2; also elsewhere on the board
GPIO_DATA0: U11.1 (A1); also elsewhere on the board
GPIO_DATA1: U11.2 (A2); also elsewhere on the board
GPIO_DATA2: U11.3 (A3); also elsewhere on the board
GPIO_DATA3: U11.4 (A4); also elsewhere on the board
GPIO_DATA4: U13.1 (A1); also elsewhere on the board
GPIO_DATA5: U13.2 (A2); also elsewhere on the board
GPIO_DATA6: U13.3 (A3); also elsewhere on the board
GPIO_DATA7: U13.4 (A4); also elsewhere on the board
GPIO_DIR0: R65.1, U11.15 (DIR1); also elsewhere on the board
GPIO_DIR1: R66.1, U11.16 (DIR2); also elsewhere on the board
GPIO_DIR2: R67.1, U11.5 (DIR3); also elsewhere on the board
GPIO_DIR3: R68.1, U11.6 (DIR4); also elsewhere on the board
GPIO_DIR4: R69.1, U13.15 (DIR1); also elsewhere on the board
GPIO_DIR5: R70.1, U13.16 (DIR2); also elsewhere on the board
GPIO_DIR6: R71.1, U13.5 (DIR3); also elsewhere on the board
GPIO_DIR7: R72.1, U13.6 (DIR4); also elsewhere on the board
GPIO_OE_HW_N: U11.7 (~OE), U13.7 (~OE); also elsewhere on the board
MISO_OE_HW_N: U7.1 (~1OE); also elsewhere on the board
PORT_GATE_N: U6.1 (~1OE), U6.16 (~2OE); also elsewhere on the board
SPI_CS0_TGT: R60.2, U6.13 (2B1); also elsewhere on the board
SPI_CS1_TGT: R61.2, U6.12 (2B2); also elsewhere on the board
SPI_MISO_RAW: R64.1, U7.15 (1B1)
SPI_MISO_TGT: R64.2; also elsewhere on the board
SPI_MOSI_TGT: R63.1, U6.14 (1B2); also elsewhere on the board
SPI_SCK_TGT: R62.1, U6.15 (1B1); also elsewhere on the board
T_CS0: R58.2, U6.8 (2A1); also elsewhere on the board
T_CS1: R59.2, U6.9 (2A2); also elsewhere on the board
T_MISO: U7.6 (1A1); also elsewhere on the board
T_MOSI: U6.7 (1A2); also elsewhere on the board
T_SCK: U6.6 (1A1); also elsewhere on the board
UART_OE_HW_N: U10.1 (~1OE), U10.16 (~2OE); also elsewhere on the board
UART_RXD_RAW: R56.2, R57.2, U10.13 (2B1)
UART_RXD_TGT: R56.1; also elsewhere on the board
UART_RX_MCU: U10.8 (2A1); also elsewhere on the board
UART_TXD_RAW: R55.1, U10.15 (1B1)
UART_TXD_TGT: R55.2; also elsewhere on the board
UART_TX_MCU: U10.6 (1A1); also elsewhere on the board

Notes on the sheet:
• PCA9306 EN/VREF2 driven from gated I2Cn_EN_DRV via 200k (no backfeed into an unpowered target).
• UART: bank 1 bridge->target, bank 2 target->bridge, fixed. SPI: U6 target->FPGA, U7 MISO only.
• VCCA = +3V3, VCCB = VTREF_IO (1.65-3.6 V); DIR/OE referenced to VCCA; Ioff isolates when unpowered.
TARGET LEVEL TRANSLATORS (A = +3V3 SIDE, B = VTREF SIDE)
• MCU-side I2C pull-ups 4k7 fitted; target-side 4k7 to VTREF_IO DNP (R87-R90): targets usually have their own.
• GPIO: per-bit DIR from FPGA (10k pull-down = B->A input default), common OE gated.

Schematic: fpga.kicad_sch, VDS4E Bridge One - iCE40UP5K SPI/GPIO bus engine

Parts:
C30, C68, C70: 1u; C_0402_1005Metric
C31, C34, C36, C71, C72, C73: 4u7; C_0603_1608Metric
C32, C33, C35, C37, C38, C39, C40, C41, C42, C74: 100n; C_0402_1005Metric
C63: 100n; C_0402_1005Metric; not fitted
C64: 1n 25V C0G; C_0402_1005Metric
C69: 1u; C_0402_1005Metric; not fitted
D3: LINK; LED_0603_1608Metric
D4: FPGA; LED_0603_1608Metric
D5: VTREF; LED_0603_1608Metric
R13: 2k2; R_0402_1005Metric
R30: 100R; R_0402_1005Metric
R32, R33, R34, R86: 10k; R_0402_1005Metric
R99: 147k 1%; R_0402_1005Metric
R100: 100k 1%; R_0402_1005Metric
R101: 100k; R_0402_1005Metric
U3: iCE40UP5K-SG48I; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm; MPN ICE40UP5K-SG48I
U4: APS6404L 8MB; SOIC-8_3.9x4.9mm_P1.27mm; MPN APS6404L-3SQR-SN
U5: TLV75712P; SOT-23-5; MPN TLV75712PDBVR
U17: TPS22917DBV; SOT-23-6; MPN TPS22917DBVR
U22: APS6404L 8MB (DNP, 16MB option); SOIC-8_3.9x4.9mm_P1.27mm; MPN APS6404L-3SQR-SN; not fitted
U23: TPS3808G01; SOT-23-6; MPN TPS3808G01DBVR
Y1: 12MHz 3V3; Oscillator_SMD_YXC_2016-4Pin_2.0x1.6mm; MPN OT201612MJBA4SL

Connections:
CLK_12M: U3.35 (IOT_46b_G0), Y1.3 (OUT)
FPGA_1V2: C31.1, C32.1, C33.1, C73.1, R30.1, U3.5 (VCC), U3.30 (VCC), U5.5 (OUT); also elsewhere on the board
FPGA_3V3: C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C63.1, C68.1, C69.1, C71.1, C72.1, R13.1, R33.1, R34.1, R86.1, U3.1 (VCCIO_2), U3.22 (SPI_VCCIO1), U3.24 (VPP_2V5), U3.33 (VCCIO_0), U4.8 (VDD), U17.5 (QOD), U17.6 (VOUT), U22.8 (VDD), Y1.1 (EN), Y1.4 (Vdd); also elsewhere on the board
FPGA_3V3_CT: C64.1, U17.4 (CT)
FPGA_CDONE: R13.2, U3.7 (CDONE); also elsewhere on the board
FPGA_CRESET_N: U3.8 (~CRESET); also elsewhere on the board
FPGA_IRQ: U3.13 (IOB_24a); also elsewhere on the board
FPGA_MISO: U3.14 (IOB_32a_SPI_SO); also elsewhere on the board
FPGA_MOSI: U3.17 (IOB_33b_SPI_SI); also elsewhere on the board
FPGA_RAILS_OK: R101.2, U17.3 (ON), U23.1 (~RESET)
FPGA_SCK: R33.2, U3.15 (IOB_34a_SPI_SCK); also elsewhere on the board
FPGA_SS_N: R32.1, U3.16 (IOB_35b_SPI_SS); also elsewhere on the board
FPGA_VCCPLL: C34.1, C35.1, R30.2, R99.1, U3.29 (VCCPLL); also elsewhere on the board
GPIO_DATA0: U3.23 (IOT_37a); also elsewhere on the board
GPIO_DATA1: U3.25 (IOT_36b); also elsewhere on the board
GPIO_DATA2: U3.26 (IOT_39a); also elsewhere on the board
GPIO_DATA3: U3.27 (IOT_38b); also elsewhere on the board
GPIO_DATA4: U3.28 (IOT_41a); also elsewhere on the board
GPIO_DATA5: U3.31 (IOT_42b); also elsewhere on the board
GPIO_DATA6: U3.32 (IOT_43a); also elsewhere on the board
GPIO_DATA7: U3.34 (IOT_44b); also elsewhere on the board
GPIO_DIR0: U3.36 (IOT_48b); also elsewhere on the board
GPIO_DIR1: U3.38 (IOT_50b); also elsewhere on the board
GPIO_DIR2: U3.42 (IOT_51a); also elsewhere on the board
GPIO_DIR3: U3.43 (IOT_49a); also elsewhere on the board
GPIO_DIR4: U3.2 (IOB_6a); also elsewhere on the board
GPIO_DIR5: U3.3 (IOB_9b); also elsewhere on the board
GPIO_DIR6: U3.4 (IOB_8a); also elsewhere on the board
GPIO_DIR7: U3.45 (IOB_5b); also elsewhere on the board
GPIO_OE_N: U3.46 (IOB_0a); also elsewhere on the board
LED_FPGA_K: D4.1 (K), U3.39 (RGB0)
LED_LINK_K: D3.1 (K), U3.40 (RGB1)
LED_VTREF_K: D5.1 (K), U3.41 (RGB2)
PSRAM_CS1_N: R86.2, U3.20 (IOB_25b_G3), U22.1 (~CE)
PSRAM_CS_N: R34.2, U3.18 (IOB_31b), U4.1 (~CE)
PSRAM_IO0: U3.19 (IOB_29b), U4.5 (SI/SIO0), U22.5 (SI/SIO0)
PSRAM_IO1: U3.21 (IOB_23b), U4.2 (SO/SIO1), U22.2 (SO/SIO1)
PSRAM_IO2: U3.47 (IOB_2a), U4.3 (SIO2), U22.3 (SIO2)
PSRAM_IO3: U3.48 (IOB_4a), U4.7 (SIO3), U22.7 (SIO3)
PSRAM_SCK: U3.44 (IOB_3b_G6), U4.6 (SCLK), U22.6 (SCLK)
T_CS0: U3.9 (IOB_16a); also elsewhere on the board
T_CS1: U3.10 (IOB_18a); also elsewhere on the board
T_MISO: U3.11 (IOB_20a); also elsewhere on the board
T_MISO_OE_N: U3.12 (IOB_22a); also elsewhere on the board
T_MOSI: U3.6 (IOB_13b); also elsewhere on the board
T_SCK: U3.37 (IOT_45a_G1); also elsewhere on the board
VCCPLL_SENSE: R99.2, R100.1, U23.5 (SENSE)

Notes on the sheet:
• PSRAM: 8 MB fitted, second 8 MB footprint DNP (pin 20). 32 MB needs 2 more CS pins (open).
• READ 0x03 arbitrary address ~1 MHz; FAST_READ 0x0B ~20 MHz (calculated, research/spi-backing-memory.md).
• Sequence: TPS3808G01 releases FPGA_RAILS_OK 20 ms after VCCPLL (lags core) > 1.00 V (147k/100k); then TPS22917 ramps FPGA_3V3 ~1.8 V/ms.
• RGB0-2 current sinks drive the FPGA / LINK / VTREF LEDs (anodes on +3V3, no series R).
• Pins per research/ice40-pin-plan.md: CLK on G0/PLL pin 35, target SCK on G1 pin 37.
• Configured by the S3 over SPI (slave mode, no config flash); same 4 wires become the data link.
ICE40UP5K SPI/GPIO BUS ENGINE

Schematic: gating.kicad_sch, VDS4E Bridge One - Target isolation logic + VTREF sense

Parts:
C43, C44, C45, C47, C48, C75: 100n; C_0402_1005Metric
C46: 1u; C_0402_1005Metric
Q1: DMG2305UX; SOT-23; MPN DMG2305UX-7
Q2: 2N7002; SOT-23; MPN 2N7002
R35, R36, R37, R38, R97, R98: 100k; R_0402_1005Metric
R39, R40: 10k; R_0402_1005Metric
R41: 10R; R_0402_1005Metric
R42, R43: 470k 1%; R_0402_1005Metric
R44: 1k; R_0402_1005Metric
R45: 100k 1%; R_0402_1005Metric
R46: 30k 1%; R_0402_1005Metric
R91, R92: 47k 1%; R_0402_1005Metric
R95: 3.0M 1%; R_0402_1005Metric
R96: 750k 1%; R_0402_1005Metric
U18, U19: SN74LVC2G32DCU; VSSOP-8_2.3x2mm_P0.5mm; MPN SN74LVC2G32DCUR
U20: SN74LVC2G02DCU; VSSOP-8_2.3x2mm_P0.5mm; MPN SN74LVC2G02DCUR
U21, U24: TLV7011DBV; SOT-23-5; MPN TLV7011DBVR

Connections:
FPGA_3V3: R39.1, R40.1; also elsewhere on the board
GPIO_OE_HW_N: R36.2, U19.7; also elsewhere on the board
GPIO_OE_N: R39.2, U19.1; also elsewhere on the board
I2C0_OFF: U20.1; also elsewhere on the board
I2C1_OFF: U20.5; also elsewhere on the board
MISO_OE_HW_N: R37.2, U19.3; also elsewhere on the board
PORT_GATE_N: R38.2, U18.6, U18.7, U19.2, U19.6, U20.2, U20.6; also elsewhere on the board
PORT_OE_N: U18.1; also elsewhere on the board
T_MISO_OE_N: R40.2, U19.5; also elsewhere on the board
UART_OE_HW_N: R35.2, U18.3; also elsewhere on the board
UART_OE_N: U18.5; also elsewhere on the board
VREF_LOW: R45.2, R46.1, U21.3 (+), U24.3 (+)
VTREF: Q1.2 (S), R42.1, R91.1, R95.1, R97.1; also elsewhere on the board
VTREF_ADC: C47.1, R44.2; also elsewhere on the board
VTREF_BAD: U18.2, U21.1
VTREF_CMP: R91.2, R92.1, U21.4 (-)
VTREF_DIV: R42.2, R43.1, R44.1
VTREF_OK_DRV: Q2.1 (G), R98.1, U24.1
VTREF_OVDIV: R95.2, R96.1, U24.4 (-)
VTREF_PFET_G: Q1.1 (G), Q2.3 (D), R97.2
VTREF_PROT: Q1.3 (D), R41.1

Notes on the sheet:
• VTREF is an input reference only: 470k/470k divider keeps backfeed ~3 uA.
• Global wins: PORT_GATE_N = PORT_OE_N OR VTREF_BAD; every port enable is gated by it in hardware.
TARGET ISOLATION LOGIC + VTREF SENSE
• Reset default = isolated (pull-ups on *_OE_N / *_OFF, FPGA outputs Hi-Z until configured).
• Ref: research/target-interface-spec.md, research/pinouts-and-gates.md
• OVP: Q1 P-FET passes VTREF only while U24 sees VTREF < 3.81 V (3.0M/750k vs VREF_LOW) and +3V3 is up; else VTREF_IO is cut.
• VTREF_BAD when VTREF < ~1.5 V (TLV7011 vs 0.76 V ref, own unfiltered 47k/47k divider: fast); runs from +3V3.
• Q2 (60 V) takes the fault voltage instead of the comparator output. Ref: research/vtref-ovp-and-fpga-supervisor.md

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
Board: 4 copper layers, 215 parts (180 on the bottom side), 145 nets, no tracks yet.

Other parts of the board:
D12, D13: BZT52C3V6; D_SOD-123
DS1: OLED 128x64 0.96in (candidate); OLED_0.96in_128x64_Panel
H1, H2, H3, H4: M2.5; MountingHole_2.7mm_M2.5_Pad_Via

Their connections:
AUX5_OVP: D12.1; also elsewhere on the board
AUX5_UVLO: D13.1; also elsewhere on the board
